## config/boards/shields/xiao_esp32c3/Kconfig.defconfig
```kconfig
config ZMK_KEYBOARD_NAME
    default "Taipo-Xiao-C3"

config ZMK_SPLIT
    default n
```
